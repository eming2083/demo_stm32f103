# Keil uVision project project.uvprojx, settings and files
target demo_512k (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00018000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: rtu_bootloader +hex
  BeforeMake: tools\new2old.bat
  AfterMake: fromelf --bin !L --output output\new_512k.bin
  AfterMake: tools\mkpatch.bat
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: BOOTLOADER,USER_APP,FLASH_SIZE_512K
  c include: ..\src\st_lib\cmsis;..\src\st_lib\inc;..\src\st_lib\src;..\src\components\ringBuffer;..\src\components\atomlib;..\src\components\ymodem;..\src\user;..\src\user\bsp;..\src\user\lib;..\src\user\inc;..\src\user\db;..\src\user\app;..\src\user\task
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group CMSIS
    ../src/st_lib/cmsis/: startup_stm32f10x_hd.s system_stm32f10x.c core_cm3.c
  group StdPeriph_Driver
    ../src/st_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group bsp
    ../src/user/bsp/: stm32f10x_it.c bsp.c led.c uart.c flash.c rtc.c sys_rst.c sys_time.c
  group lib
    ../src/user/lib/: mylib.c crc32.c
  group components
    ../src/components/ringBuffer/: ringBuffer.c
    ../src/components/atomlib/: ustdio.c shell.c
  group db
    ../src/user/db/: db.c
  group app
    ../src/user/app/: iap.c ymodem.c shell_port.c
    ../src/user/inc/: usr_cfg.h
  group task
    ../src/user/task/: main.c
target demo_1024k (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VG STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: as above
  output: rtu_bootloader +hex
  BeforeMake: tools\new2old.bat
  AfterMake: fromelf --bin !L --output output\new_1024k.bin
  AfterMake: tools\mkpatch.bat
  c flags: OneElfS=1 uC99=1 wLevel=2
  c define: BOOTLOADER,USER_APP,FLASH_SIZE_1024K
  c include: ..\src\st_lib\cmsis;..\src\st_lib\inc;..\src\st_lib\src;..\src\components\ringBuffer;..\src\components\atomlib;..\src\user;..\src\user\bsp;..\src\user\lib;..\src\user\inc;..\src\user\db;..\src\user\app;..\src\user\task
  library: MicroLIB
  memory RVCT4: ROM 0x8008000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x18000
software components: CMSIS:CORE 5.4.0
